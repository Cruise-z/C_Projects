//
// Created by 赵睿智 on 2022/4/21.
//

#include "Stream_Cipher.h"
#include <stdio.h>
#include <stdint.h>
#include <gmp.h>
#include <time.h>
#include <stdbool.h>
#include <string.h>
#include <stdlib.h>
#include <assert.h>
#include <math.h>
#include "../My_Matrix_cal/My_Matrix_cal.h"
#include "../My_BigNum_GF_cal/My_BigNum_GF_cal.h"
#include "../conversion/lib_Convert.h"
#include "../SM4/SM4_enc_dec.h"

void BBS_random(mpz_t *ans, int digit, mpz_t p, mpz_t q, mpz_t s){
    mpz_t result, n, temp1, x, b, two;
    mpz_init_set_ui(result, 0);
    mpz_init(n);
    mpz_init(temp1);
    mpz_init(x);
    mpz_mul(n, p, q);
    mpz_init(b);
    mpz_init_set_ui(two, 2);
    //计算种子
    mpz_pow_ui(temp1, s, 2);
    mpz_mod(x, temp1, n);
    int cnt;
    for(cnt = 0; cnt < digit; cnt++){
        mpz_pow_ui(x, x, 2);
        mpz_mod(x, x, n);
        mpz_mod_ui(b, x, 2);
        mpz_pow_ui(temp1, two, cnt);
        mpz_mul(temp1, temp1, b);
        mpz_add(result, result, temp1);
    }
    mpz_set(*ans, result);
}

uint32_t* Mersenne_Twister(uint32_t seed, int num){
    seed_Init(seed);
    twist();
    uint32_t *ans = malloc(sizeof(uint32_t)*num);
    int cnt;
    for(cnt = 0; cnt < num; cnt++)
        ans[cnt] = extract();
    return ans;
}

void seed_Init(const uint32_t seed){
    uint32_t  i;
    MT[0] = seed;
    for ( i = 1; i < N; i++ )
        MT[i] = (F * (MT[i - 1] ^ (MT[i - 1] >> 30)) + i);
    Index = N;
}

void twist(){
    uint32_t  i, x, xA;
    for ( i = 0; i < N; i++ )
    {
        x = (MT[i] & MASK_UPPER) + (MT[(i + 1) % N] & MASK_LOWER);
        xA = x >> 1;
        if ( x & 0x1 )
        {
            xA ^= A;
        }
        MT[i] = MT[(i + M) % N] ^ xA;
    }
    Index = 0;
}

uint32_t extract(){
    uint32_t  y;
    int i = Index;
    if ( Index >= N )
    {
        twist();
        i = Index;
    }
    y = MT[i];
    Index = i + 1;
    y ^= (y >> U);
    y ^= (y << S) & B;
    y ^= (y << T) & C;
    y ^= (y >> L);
    return y;
}

uint32_t ZUC_S0_box[16][16] = {0x3e, 0x72, 0x5b, 0x47, 0xca, 0xe0, 0x00, 0x33, 0x04, 0xd1, 0x54, 0x98, 0x09, 0xb9, 0x6d, 0xcb,
                               0x7b, 0x1b, 0xf9, 0x32, 0xaf, 0x9d, 0x6a, 0xa5, 0xb8, 0x2d, 0xfc, 0x1d, 0x08, 0x53, 0x03, 0x90,
                               0x4d, 0x4e, 0x84, 0x99, 0xe4, 0xce, 0xd9, 0x91, 0xdd, 0xb6, 0x85, 0x48, 0x8b, 0x29, 0x6e, 0xac,
                               0xcd, 0xc1, 0xf8, 0x1e, 0x73, 0x43, 0x69, 0xc6, 0xb5, 0xbd, 0xfd, 0x39, 0x63, 0x20, 0xd4, 0x38,
                               0x76, 0x7d, 0xb2, 0xa7, 0xcf, 0xed, 0x57, 0xc5, 0xf3, 0x2c, 0xbb, 0x14, 0x21, 0x06, 0x55, 0x9b,
                               0xe3, 0xef, 0x5e, 0x31, 0x4f, 0x7f, 0x5a, 0xa4, 0x0d, 0x82, 0x51, 0x49, 0x5f, 0xba, 0x58, 0x1c,
                               0x4a, 0x16, 0xd5, 0x17, 0xa8, 0x92, 0x24, 0x1f, 0x8c, 0xff, 0xd8, 0xae, 0x2e, 0x01, 0xd3, 0xad,
                               0x3b, 0x4b, 0xda, 0x46, 0xeb, 0xc9, 0xde, 0x9a, 0x8f, 0x87, 0xd7, 0x3a, 0x80, 0x6f, 0x2f, 0xc8,
                               0xb1, 0xb4, 0x37, 0xf7, 0x0a, 0x22, 0x13, 0x28, 0x7c, 0xcc, 0x3c, 0x89, 0xc7, 0xc3, 0x96, 0x56,
                               0x07, 0xbf, 0x7e, 0xf0, 0x0b, 0x2b, 0x97, 0x52, 0x35, 0x41, 0x79, 0x61, 0xa6, 0x4c, 0x10, 0xfe,
                               0xbc, 0x26, 0x95, 0x88, 0x8a, 0xb0, 0xa3, 0xfb, 0xc0, 0x18, 0x94, 0xf2, 0xe1, 0xe5, 0xe9, 0x5d,
                               0xd0, 0xdc, 0x11, 0x66, 0x64, 0x5c, 0xec, 0x59, 0x42, 0x75, 0x12, 0xf5, 0x74, 0x9c, 0xaa, 0x23,
                               0x0e, 0x86, 0xab, 0xbe, 0x2a, 0x02, 0xe7, 0x67, 0xe6, 0x44, 0xa2, 0x6c, 0xc2, 0x93, 0x9f, 0xf1,
                               0xf6, 0xfa, 0x36, 0xd2, 0x50, 0x68, 0x9e, 0x62, 0x71, 0x15, 0x3d, 0xd6, 0x40, 0xc4, 0xe2, 0x0f,
                               0x8e, 0x83, 0x77, 0x6b, 0x25, 0x05, 0x3f, 0x0c, 0x30, 0xea, 0x70, 0xb7, 0xa1, 0xe8, 0xa9, 0x65,
                               0x8d, 0x27, 0x1a, 0xdb, 0x81, 0xb3, 0xa0, 0xf4, 0x45, 0x7a, 0x19, 0xdf, 0xee, 0x78, 0x34, 0x60};

uint32_t ZUC_S1_box[16][16] = {0x55, 0xc2, 0x63, 0x71, 0x3b, 0xc8, 0x47, 0x86, 0x9f, 0x3c, 0xda, 0x5b, 0x29, 0xaa, 0xfd, 0x77,
                               0x8c, 0xc5, 0x94, 0x0c, 0xa6, 0x1a, 0x13, 0x00, 0xe3, 0xa8, 0x16, 0x72, 0x40, 0xf9, 0xf8, 0x42,
                               0x44, 0x26, 0x68, 0x96, 0x81, 0xd9, 0x45, 0x3e, 0x10, 0x76, 0xc6, 0xa7, 0x8b, 0x39, 0x43, 0xe1,
                               0x3a, 0xb5, 0x56, 0x2a, 0xc0, 0x6d, 0xb3, 0x05, 0x22, 0x66, 0xbf, 0xdc, 0x0b, 0xfa, 0x62, 0x48,
                               0xdd, 0x20, 0x11, 0x06, 0x36, 0xc9, 0xc1, 0xcf, 0xf6, 0x27, 0x52, 0xbb, 0x69, 0xf5, 0xd4, 0x87,
                               0x7f, 0x84, 0x4c, 0xd2, 0x9c, 0x57, 0xa4, 0xbc, 0x4f, 0x9a, 0xdf, 0xfe, 0xd6, 0x8d, 0x7a, 0xeb,
                               0x2b, 0x53, 0xd8, 0x5c, 0xa1, 0x14, 0x17, 0xfb, 0x23, 0xd5, 0x7d, 0x30, 0x67, 0x73, 0x08, 0x09,
                               0xee, 0xb7, 0x70, 0x3f, 0x61, 0xb2, 0x19, 0x8e, 0x4e, 0xe5, 0x4b, 0x93, 0x8f, 0x5d, 0xdb, 0xa9,
                               0xad, 0xf1, 0xae, 0x2e, 0xcb, 0x0d, 0xfc, 0xf4, 0x2d, 0x46, 0x6e, 0x1d, 0x97, 0xe8, 0xd1, 0xe9,
                               0x4d, 0x37, 0xa5, 0x75, 0x5e, 0x83, 0x9e, 0xab, 0x82, 0x9d, 0xb9, 0x1c, 0xe0, 0xcd, 0x49, 0x89,
                               0x01, 0xb6, 0xbd, 0x58, 0x24, 0xa2, 0x5f, 0x38, 0x78, 0x99, 0x15, 0x90, 0x50, 0xb8, 0x95, 0xe4,
                               0xd0, 0x91, 0xc7, 0xce, 0xed, 0x0f, 0xb4, 0x6f, 0xa0, 0xcc, 0xf0, 0x02, 0x4a, 0x79, 0xc3, 0xde,
                               0xa3, 0xef, 0xea, 0x51, 0xe6, 0x6b, 0x18, 0xec, 0x1b, 0x2c, 0x80, 0xf7, 0x74, 0xe7, 0xff, 0x21,
                               0x5a, 0x6a, 0x54, 0x1e, 0x41, 0x31, 0x92, 0x35, 0xc4, 0x33, 0x07, 0x0a, 0xba, 0x7e, 0x0e, 0x34,
                               0x88, 0xb1, 0x98, 0x7c, 0xf3, 0x3d, 0x60, 0x6c, 0x7b, 0xca, 0xd3, 0x1f, 0x32, 0x65, 0x04, 0x28,
                               0x64, 0xbe, 0x85, 0x9b, 0x2f, 0x59, 0x8a, 0xd7, 0xb0, 0x25, 0xac, 0xaf, 0x12, 0x03, 0xe2, 0xf2};

uint32_t R1 = 0, R2 = 0;

void LFSR_init_Mode(uint32_t (*reg)[16], uint32_t u){
    uint64_t s, v;
    v = (1ull<<15)*(*reg)[15] + (1ull<<17)*(*reg)[13] + (1ull<<21)*(*reg)[10]
        + (1ull<<20)*(*reg)[4] + (1ull+(1ull<<8))*(*reg)[0];
    v %= ((1ull<<31)-1);
    s = (v+u) % ((1ull<<31)-1);
    if(s == 0)
        s = ((1ull<<31)-1);
    int cnt;
    for(cnt = 0; cnt < 15; cnt++)
        (*reg)[cnt] = (*reg)[cnt+1];
    (*reg)[15] = s;
}

void LFSR_work_Mode(uint32_t (*reg)[16]){
    uint64_t s;
    s = (1ull<<15)*(*reg)[15] + (1ull<<17)*(*reg)[13] + (1ull<<21)*(*reg)[10]
        + (1ull<<20)*(*reg)[4] + (1ull+(1ull<<8))*(*reg)[0];
    s %= ((1ull<<31)-1);
    if(s == 0)
        s = ((1ull<<31)-1);
    int cnt;
    for(cnt = 0; cnt < 15; cnt++)
        (*reg)[cnt] = (*reg)[cnt+1];
    (*reg)[15] = s;
}

void BR(uint32_t (*X)[4], const uint32_t reg[16]){
    (*X)[0] = ((reg[15]>>15)<<16) + (reg[14]&0x0000ffff);
    (*X)[1] = ((reg[11]&0x0000ffff)<<16) + (reg[ 9]>>15);
    (*X)[2] = ((reg[ 7]&0x0000ffff)<<16) + (reg[ 5]>>15);
    (*X)[3] = ((reg[ 2]&0x0000ffff)<<16) + (reg[ 0]>>15);
}

uint32_t L1(uint32_t x){
    return x ^ r_sl(x, 2) ^ r_sl(x, 10) ^ r_sl(x, 18) ^r_sl(x, 24);
}

uint32_t L2(uint32_t x){
    return x ^ r_sl(x, 8) ^ r_sl(x, 14) ^ r_sl(x, 22) ^r_sl(x, 30);
}

uint32_t ZUC_S(uint32_t x){
    uint32_t x0 = x >> 24;
    uint32_t x1 = (x & 0x00ff0000) >> 16;
    uint32_t x2 = (x & 0x0000ff00) >> 8;
    uint32_t x3 = (x & 0x000000ff);
    return (ZUC_S0_box[x0>>4][x0&0xf] << 24) + (ZUC_S1_box[x1>>4][x1&0xf] << 16)
         + (ZUC_S0_box[x2>>4][x2&0xf] <<  8) + ZUC_S1_box[x3>>4][x3&0xf];
}

void ZUC_F(uint32_t *W, uint32_t X0, uint32_t X1, uint32_t X2){
    uint32_t w1, w2;
    *W = (X0^R1) + R2;
    w1 = R1 + X1;
    w2 = R2 ^ X2;
    R1 = ZUC_S(L1(((w1&0x0000ffff)<<16)+((w2&0xffff0000)>>16)));
    R2 = ZUC_S(L2(((w2&0x0000ffff)<<16)+((w1&0xffff0000)>>16)));
}

void store_key(uint32_t (*reg)[16], const uint32_t key[16], const uint32_t IV[16]){
    (*reg)[0x0] = (key[0x0]<<23) + (0x44d7<<8) + IV[0x0];
    (*reg)[0x1] = (key[0x1]<<23) + (0x26bc<<8) + IV[0x1];
    (*reg)[0x2] = (key[0x2]<<23) + (0x626b<<8) + IV[0x2];
    (*reg)[0x3] = (key[0x3]<<23) + (0x135e<<8) + IV[0x3];
    (*reg)[0x4] = (key[0x4]<<23) + (0x5789<<8) + IV[0x4];
    (*reg)[0x5] = (key[0x5]<<23) + (0x35e2<<8) + IV[0x5];
    (*reg)[0x6] = (key[0x6]<<23) + (0x7135<<8) + IV[0x6];
    (*reg)[0x7] = (key[0x7]<<23) + (0x09af<<8) + IV[0x7];
    (*reg)[0x8] = (key[0x8]<<23) + (0x4d78<<8) + IV[0x8];
    (*reg)[0x9] = (key[0x9]<<23) + (0x2f13<<8) + IV[0x9];
    (*reg)[0xa] = (key[0xa]<<23) + (0x6bc4<<8) + IV[0xa];
    (*reg)[0xb] = (key[0xb]<<23) + (0x1af1<<8) + IV[0xb];
    (*reg)[0xc] = (key[0xc]<<23) + (0x5e26<<8) + IV[0xc];
    (*reg)[0xd] = (key[0xd]<<23) + (0x3c4d<<8) + IV[0xd];
    (*reg)[0xe] = (key[0xe]<<23) + (0x789a<<8) + IV[0xe];
    (*reg)[0xf] = (key[0xf]<<23) + (0x47ac<<8) + IV[0xf];
}

void ZUC_getkey(uint32_t (*key)[16], const char *hex_32byte_str){
    hex_32byte_str += 2;
    int i;
    for(i = 0; i < 16; i++)
        (*key)[i] = hex2bin_index(hex_32byte_str[2*i])*16
                    + hex2bin_index(hex_32byte_str[2*i+1]);
}

void ZUC_getIV(uint32_t (*IV)[16], const char *hex_32byte_str){
    hex_32byte_str += 2;
    int i;
    for(i = 0; i < 16; i++)
        (*IV)[i] = hex2bin_index(hex_32byte_str[2*i])*16
                    + hex2bin_index(hex_32byte_str[2*i+1]);
}

void ZUC(char *key_str, char *IV_str, int round){
    int cnt;
    uint32_t key[16], IV[16], reg[16], X[4], W;
    ZUC_getkey(&key, key_str);
    ZUC_getIV(&IV, IV_str);
    store_key(&reg, key, IV);
    R1 = 0;
    R2 = 0;
    for(cnt = 0; cnt < 32; cnt++){
        BR(&X, reg);
        ZUC_F(&W, X[0], X[1], X[2]);
        LFSR_init_Mode(&reg, W>>1);
    }
    BR(&X, reg);
    ZUC_F(&W, X[0], X[1], X[2]);
    LFSR_work_Mode(&reg);
    for(cnt = 0; cnt < round; cnt++){
        BR(&X, reg);
        ZUC_F(&W, X[0], X[1], X[2]);
        W ^= X[3];
        printf("0x%08x\n", W);
        LFSR_work_Mode(&reg);
    }
}